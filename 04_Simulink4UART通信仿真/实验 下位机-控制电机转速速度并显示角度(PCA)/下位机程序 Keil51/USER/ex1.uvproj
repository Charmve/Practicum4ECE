# Keil uVision project ex1.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8A8K64S4A12 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: ex1 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\SYSTEM;..\HARDWARE;..\USER
  group User
    ./: main.c
  group SYS
    ../SYSTEM/: GPIO.c Serial.c AD.c
  group Hardware
    ../HARDWARE/: oled.c Motor.c
  group Note
    ../Note/: 说明.txt
